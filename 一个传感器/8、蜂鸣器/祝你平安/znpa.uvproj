# Keil uVision project znpa.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89E564 SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: znpa +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: znpa.asm
