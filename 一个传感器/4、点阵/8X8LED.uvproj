# Keil uVision project 8X8LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: M6032 Acer Labs
  cpu: IRAM(0-0xFF) CLOCK(33000000) XRAM (0-0xFF) MODDP2
  output: 8X8LED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 8X8LED.c
