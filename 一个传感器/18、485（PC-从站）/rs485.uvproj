# Keil uVision project rs485.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89E564RD SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: rs485 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: rs485.c
